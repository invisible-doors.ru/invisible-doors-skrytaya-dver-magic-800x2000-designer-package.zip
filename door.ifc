Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView]
File name: door.ifc
Time: 2026-09-09T00:00:00
Author: INVISIBLE DOORS
Organization: INVISIBLE DOORS
Written by: Showroom R15
Made in: Showroom R15

# IfcBuildingStorey, Finished floor
In: Building
Elevation: 0 m

# IfcDoor, Скрытая дверь MAGIC
In: Finished floor
Description: Coordination geometry; not a native wall-hosted family; OverallHeight: 2 m; OverallWidth: 0.8 m; PredefinedType: DOOR; OperationType: SLIDING_TO_RIGHT
INVISIBLE_DOORS_Configuration - Manufacturer: INVISIBLE DOORS; Model: skrytaya-dver-magic; Finish: RAL 7032; FinishOutside: Эмаль · RAL 7032 · матовая; FinishInside: Как снаружи · Эмаль · RAL 7032 · матовая; Opening: right-out; Source: https://invisible-doors.ru/public_files/recommendations.pdf; GeometryUse: interior visualisation and coordination; simplified frame and hardware; LeafWidthMm: 800; LeafHeightMm: 2000; LeafThicknessMm: 40; RecommendedOpeningWidthMm: 600; RecommendedOpeningHeightMm: 1900
